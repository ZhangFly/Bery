# Keil uVision project Bery.uvprojx, settings and files
target Master (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Master +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\APP\sample;..\APP\collect;..\SERVICE\buffer;..\SERVICE\net;..\SERVICE\sensor;..\SERVICE\transmit;..\HARDWARE\factory;..\HARDWARE\house\adc;..\HARDWARE\house\gpiox;..\HARDWARE\house\idac;..\HARDWARE\house\led;..\HARDWARE\house\sensor;..\HARDWARE\house\spi;..\HARDWARE\house\tim;..\HARDWARE\house\usart
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group APP_SAMPLE
    ../APP/sample/: sample.c
  group APP_COLLECT
    ../APP/collect/: collect.c
  group SERVICE_BUFFER
    ../SERVICE/buffer/: buffer.c iterator.c
  group SERVICE_SENSOR
    ../SERVICE/sensor/: scan.c sensor.c
  group SERVICE_NET
    ../SERVICE/net/: net.c net_master.c net_slave.c conn.c
  group SERIVCE_TRANSMIT
    ../SERVICE/transmit/: tansmit.c transfer.c
  group HARDWARE_HOUSE
    ../HARDWARE/house/adc/: adc1.c
    ../HARDWARE/house/idac/: idac1.c
    ../HARDWARE/house/gpiox/: gpiox.c
    ../HARDWARE/house/spi/: spi1.c spi2.c
    ../HARDWARE/house/tim/: tim2.c tim3.c
    ../HARDWARE/house/usart/: usart1.c
    ../HARDWARE/house/led/: led1.c led2.c led3.c led4.c
  group HARDWARE_FACTORY
    ../HARDWARE/FACTORY/: hardware_factory.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c misc.c stm32f10x_spi.c stm32f10x_adc.c stm32f10x_tim.c
